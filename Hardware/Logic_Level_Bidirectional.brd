# Repository crazyelectron-io/Logic_Level_Bidi (continued)

## EAGLE design Production Files/Logic_Level_Bidirectional-GiantPanel-v01.brd

Board: 2 copper layers, 247.4 x 238.3 mm, 4044 parts (896 on the bottom side), 2464 nets.

Parts (part):
E$1, E$6, E$9, E$12: FIDUCIAL-1.5X3
E$2, E$3, E$4, E$5, E$7, E$8, E$10, E$11: FIDUCIAL-1X2
JP1, JP2, JP5, JP6, JP9, JP10, JP13, JP14, JP17, JP18, JP21, JP22, JP25, JP26, JP29, JP30, JP33, JP34, JP37, JP38, JP41, JP42, JP45, JP46, JP49, JP50, JP53, JP54, JP57, JP58, JP61, JP62, JP65, JP66, JP69, JP70, JP73, JP74, JP77, JP78, JP81, JP82, JP85, JP86, JP89, JP90, JP93, JP94, JP97, JP98, JP101, JP102, JP105, JP106, JP109, JP110, JP113, JP114, JP117, JP118, JP121, JP122, JP125, JP126, JP129, JP130, JP133, JP134, JP137, JP138, JP141, JP142, JP145, JP146, JP149, JP150, JP153, JP154, JP157, JP158, JP161, JP162, JP165, JP166, JP169, JP170, JP173, JP174, JP177, JP178, JP181, JP182, JP185, JP186, JP189, JP190, JP193, JP194, JP197, JP198, JP201, JP202, JP205, JP206, JP209, JP210, JP213, JP214, JP217, JP218, JP221, JP222, JP225, JP226, JP229, JP230, JP233, JP234, JP237, JP238, JP241, JP242, JP245, JP246, JP249, JP250, JP253, JP254, JP257, JP258, JP261, JP262, JP265, JP266, JP269, JP270, JP273, JP274, JP277, JP278, JP281, JP282, JP285, JP286, JP289, JP290, JP293, JP294, JP297, JP298, JP301, JP302, JP305, JP306, JP309, JP310, JP313, JP314, JP317, JP318, JP321, JP322, JP325, JP326, JP329, JP330, JP333, JP334, JP337, JP338, JP341, JP342, JP345, JP346, JP349, JP350, JP353, JP354, JP357, JP358, JP361, JP362, JP365, JP366, JP369, JP370, JP373, JP374, JP377, JP378, JP381, JP382, JP385, JP386, JP389, JP390, JP393, JP394, JP397, JP398, JP401, JP402, JP405, JP406, JP409, JP410, JP413, JP414, JP417, JP418, JP421, JP422, JP425, JP426, JP429, JP430, JP433, JP434, JP437, JP438, JP441, JP442, JP445, JP446, JP449, JP450, JP453, JP454, JP457, JP458, JP461, JP462, JP465, JP466, JP469, JP470, JP473, JP474, JP477, JP478, JP481, JP482, JP485, JP486, JP489, JP490, JP493, JP494, JP497, JP498, JP501, JP502, JP505, JP506, JP509, JP510, JP513, JP514, JP517, JP518, JP521, JP522, JP525, JP526, JP529, JP530, JP533, JP534, JP537, JP538, JP541, JP542, JP545, JP546, JP549, JP550, JP553, JP554, JP557, JP558, JP561, JP562, JP565, JP566, JP569, JP570, JP573, JP574, JP577, JP578, JP581, JP582, JP585, JP586, JP589, JP590, JP593, JP594, JP597, JP598, JP601, JP602, JP605, JP606, JP609, JP610, JP613, JP614, JP617, JP618, JP621, JP622, JP625, JP626, JP629, JP630, JP633, JP634, JP637, JP638, JP641, JP642, JP645, JP646, JP649, JP650, JP653, JP654, JP657, JP658, JP661, JP662, JP665, JP666, JP669, JP670, JP673, JP674, JP677, JP678, JP681, JP682, JP685, JP686, JP689, JP690, JP693, JP694, JP697, JP698, JP701, JP702, JP705, JP706, JP709, JP710, JP713, JP714, JP717, JP718, JP721, JP722, JP725, JP726, JP729, JP730, JP733, JP734, JP737, JP738, JP741, JP742, JP745, JP746, JP749, JP750, JP753, JP754, JP757, JP758, JP761, JP762, JP765, JP766, JP769, JP770, JP773, JP774, JP777, JP778, JP781, JP782, JP785, JP786, JP789, JP790, JP793, JP794, JP797, JP798, JP801, JP802, JP805, JP806, JP809, JP810, JP813, JP814, JP817, JP818, JP821, JP822, JP825, JP826, JP829, JP830, JP833, JP834, JP837, JP838, JP841, JP842, JP845, JP846, JP849, JP850, JP853, JP854, JP857, JP858, JP861, JP862, JP865, JP866, JP869, JP870, JP873, JP874, JP877, JP878, JP881, JP882, JP885, JP886, JP889, JP890, JP893, JP894: 1X06
JP3, JP4, JP7, JP8, JP11, JP12, JP15, JP16, JP19, JP20, JP23, JP24, JP27, JP28, JP31, JP32, JP35, JP36, JP39, JP40, JP43, JP44, JP47, JP48, JP51, JP52, JP55, JP56, JP59, JP60, JP63, JP64, JP67, JP68, JP71, JP72, JP75, JP76, JP79, JP80, JP83, JP84, JP87, JP88, JP91, JP92, JP95, JP96, JP99, JP100, JP103, JP104, JP107, JP108, JP111, JP112, JP115, JP116, JP119, JP120, JP123, JP124, JP127, JP128, JP131, JP132, JP135, JP136, JP139, JP140, JP143, JP144, JP147, JP148, JP151, JP152, JP155, JP156, JP159, JP160, JP163, JP164, JP167, JP168, JP171, JP172, JP175, JP176, JP179, JP180, JP183, JP184, JP187, JP188, JP191, JP192, JP195, JP196, JP199, JP200, JP203, JP204, JP207, JP208, JP211, JP212, JP215, JP216, JP219, JP220, JP223, JP224, JP227, JP228, JP231, JP232, JP235, JP236, JP239, JP240, JP243, JP244, JP247, JP248, JP251, JP252, JP255, JP256, JP259, JP260, JP263, JP264, JP267, JP268, JP271, JP272, JP275, JP276, JP279, JP280, JP283, JP284, JP287, JP288, JP291, JP292, JP295, JP296, JP299, JP300, JP303, JP304, JP307, JP308, JP311, JP312, JP315, JP316, JP319, JP320, JP323, JP324, JP327, JP328, JP331, JP332, JP335, JP336, JP339, JP340, JP343, JP344, JP347, JP348, JP351, JP352, JP355, JP356, JP359, JP360, JP363, JP364, JP367, JP368, JP371, JP372, JP375, JP376, JP379, JP380, JP383, JP384, JP387, JP388, JP391, JP392, JP395, JP396, JP399, JP400, JP403, JP404, JP407, JP408, JP411, JP412, JP415, JP416, JP419, JP420, JP423, JP424, JP427, JP428, JP431, JP432, JP435, JP436, JP439, JP440, JP443, JP444, JP447, JP448, JP451, JP452, JP455, JP456, JP459, JP460, JP463, JP464, JP467, JP468, JP471, JP472, JP475, JP476, JP479, JP480, JP483, JP484, JP487, JP488, JP491, JP492, JP495, JP496, JP499, JP500, JP503, JP504, JP507, JP508, JP511, JP512, JP515, JP516, JP519, JP520, JP523, JP524, JP527, JP528, JP531, JP532, JP535, JP536, JP539, JP540, JP543, JP544, JP547, JP548, JP551, JP552, JP555, JP556, JP559, JP560, JP563, JP564, JP567, JP568, JP571, JP572, JP575, JP576, JP579, JP580, JP583, JP584, JP587, JP588, JP591, JP592, JP595, JP596, JP599, JP600, JP603, JP604, JP607, JP608, JP611, JP612, JP615, JP616, JP619, JP620, JP623, JP624, JP627, JP628, JP631, JP632, JP635, JP636, JP639, JP640, JP643, JP644, JP647, JP648, JP651, JP652, JP655, JP656, JP659, JP660, JP663, JP664, JP667, JP668, JP671, JP672, JP675, JP676, JP679, JP680, JP683, JP684, JP687, JP688, JP691, JP692, JP695, JP696, JP699, JP700, JP703, JP704, JP707, JP708, JP711, JP712, JP715, JP716, JP719, JP720, JP723, JP724, JP727, JP728, JP731, JP732, JP735, JP736, JP739, JP740, JP743, JP744, JP747, JP748, JP751, JP752, JP755, JP756, JP759, JP760, JP763, JP764, JP767, JP768, JP771, JP772, JP775, JP776, JP779, JP780, JP783, JP784, JP787, JP788, JP791, JP792, JP795, JP796, JP799, JP800, JP803, JP804, JP807, JP808, JP811, JP812, JP815, JP816, JP819, JP820, JP823, JP824, JP827, JP828, JP831, JP832, JP835, JP836, JP839, JP840, JP843, JP844, JP847, JP848, JP851, JP852, JP855, JP856, JP859, JP860, JP863, JP864, JP867, JP868, JP871, JP872, JP875, JP876, JP879, JP880, JP883, JP884, JP887, JP888, JP891, JP892, JP895, JP896: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
LOGO1, LOGO3, LOGO5, LOGO7, LOGO9, LOGO11, LOGO13, LOGO15, LOGO17, LOGO19, LOGO21, LOGO23, LOGO25, LOGO27, LOGO29, LOGO31, LOGO33, LOGO35, LOGO37, LOGO39, LOGO41, LOGO43, LOGO45, LOGO47, LOGO49, LOGO51, LOGO53, LOGO55, LOGO57, LOGO59, LOGO61, LOGO63, LOGO65, LOGO67, LOGO69, LOGO71, LOGO73, LOGO75, LOGO77, LOGO79, LOGO81, LOGO83, LOGO85, LOGO87, LOGO89, LOGO91, LOGO93, LOGO95, LOGO97, LOGO99, LOGO101, LOGO103, LOGO105, LOGO107, LOGO109, LOGO111, LOGO113, LOGO115, LOGO117, LOGO119, LOGO121, LOGO123, LOGO125, LOGO127, LOGO129, LOGO131, LOGO133, LOGO135, LOGO137, LOGO139, LOGO141, LOGO143, LOGO145, LOGO147, LOGO149, LOGO151, LOGO153, LOGO155, LOGO157, LOGO159, LOGO161, LOGO163, LOGO165, LOGO167, LOGO169, LOGO171, LOGO173, LOGO175, LOGO177, LOGO179, LOGO181, LOGO183, LOGO185, LOGO187, LOGO189, LOGO191, LOGO193, LOGO195, LOGO197, LOGO199, LOGO201, LOGO203, LOGO205, LOGO207, LOGO209, LOGO211, LOGO213, LOGO215, LOGO217, LOGO219, LOGO221, LOGO223, LOGO225, LOGO227, LOGO229, LOGO231, LOGO233, LOGO235, LOGO237, LOGO239, LOGO241, LOGO243, LOGO245, LOGO247, LOGO249, LOGO251, LOGO253, LOGO255, LOGO257, LOGO259, LOGO261, LOGO263, LOGO265, LOGO267, LOGO269, LOGO271, LOGO273, LOGO275, LOGO277, LOGO279, LOGO281, LOGO283, LOGO285, LOGO287, LOGO289, LOGO291, LOGO293, LOGO295, LOGO297, LOGO299, LOGO301, LOGO303, LOGO305, LOGO307, LOGO309, LOGO311, LOGO313, LOGO315, LOGO317, LOGO319, LOGO321, LOGO323, LOGO325, LOGO327, LOGO329, LOGO331, LOGO333, LOGO335, LOGO337, LOGO339, LOGO341, LOGO343, LOGO345, LOGO347, LOGO349, LOGO351, LOGO353, LOGO355, LOGO357, LOGO359, LOGO361, LOGO363, LOGO365, LOGO367, LOGO369, LOGO371, LOGO373, LOGO375, LOGO377, LOGO379, LOGO381, LOGO383, LOGO385, LOGO387, LOGO389, LOGO391, LOGO393, LOGO395, LOGO397, LOGO399, LOGO401, LOGO403, LOGO405, LOGO407, LOGO409, LOGO411, LOGO413, LOGO415, LOGO417, LOGO419, LOGO421, LOGO423, LOGO425, LOGO427, LOGO429, LOGO431, LOGO433, LOGO435, LOGO437, LOGO439, LOGO441, LOGO443, LOGO445, LOGO447: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
LOGO2, LOGO4, LOGO6, LOGO8, LOGO10, LOGO12, LOGO14, LOGO16, LOGO18, LOGO20, LOGO22, LOGO24, LOGO26, LOGO28, LOGO30, LOGO32, LOGO34, LOGO36, LOGO38, LOGO40, LOGO42, LOGO44, LOGO46, LOGO48, LOGO50, LOGO52, LOGO54, LOGO56, LOGO58, LOGO60, LOGO62, LOGO64, LOGO66, LOGO68, LOGO70, LOGO72, LOGO74, LOGO76, LOGO78, LOGO80, LOGO82, LOGO84, LOGO86, LOGO88, LOGO90, LOGO92, LOGO94, LOGO96, LOGO98, LOGO100, LOGO102, LOGO104, LOGO106, LOGO108, LOGO110, LOGO112, LOGO114, LOGO116, LOGO118, LOGO120, LOGO122, LOGO124, LOGO126, LOGO128, LOGO130, LOGO132, LOGO134, LOGO136, LOGO138, LOGO140, LOGO142, LOGO144, LOGO146, LOGO148, LOGO150, LOGO152, LOGO154, LOGO156, LOGO158, LOGO160, LOGO162, LOGO164, LOGO166, LOGO168, LOGO170, LOGO172, LOGO174, LOGO176, LOGO178, LOGO180, LOGO182, LOGO184, LOGO186, LOGO188, LOGO190, LOGO192, LOGO194, LOGO196, LOGO198, LOGO200, LOGO202, LOGO204, LOGO206, LOGO208, LOGO210, LOGO212, LOGO214, LOGO216, LOGO218, LOGO220, LOGO222, LOGO224, LOGO226, LOGO228, LOGO230, LOGO232, LOGO234, LOGO236, LOGO238, LOGO240, LOGO242, LOGO244, LOGO246, LOGO248, LOGO250, LOGO252, LOGO254, LOGO256, LOGO258, LOGO260, LOGO262, LOGO264, LOGO266, LOGO268, LOGO270, LOGO272, LOGO274, LOGO276, LOGO278, LOGO280, LOGO282, LOGO284, LOGO286, LOGO288, LOGO290, LOGO292, LOGO294, LOGO296, LOGO298, LOGO300, LOGO302, LOGO304, LOGO306, LOGO308, LOGO310, LOGO312, LOGO314, LOGO316, LOGO318, LOGO320, LOGO322, LOGO324, LOGO326, LOGO328, LOGO330, LOGO332, LOGO334, LOGO336, LOGO338, LOGO340, LOGO342, LOGO344, LOGO346, LOGO348, LOGO350, LOGO352, LOGO354, LOGO356, LOGO358, LOGO360, LOGO362, LOGO364, LOGO366, LOGO368, LOGO370, LOGO372, LOGO374, LOGO376, LOGO378, LOGO380, LOGO382, LOGO384, LOGO386, LOGO388, LOGO390, LOGO392, LOGO394, LOGO396, LOGO398, LOGO400, LOGO402, LOGO404, LOGO406, LOGO408, LOGO410, LOGO412, LOGO414, LOGO416, LOGO418, LOGO420, LOGO422, LOGO424, LOGO426, LOGO428, LOGO430, LOGO432, LOGO434, LOGO436, LOGO438, LOGO440, LOGO442, LOGO444, LOGO446, LOGO448: OSHW-LOGOS; OSHW-LOGO-S
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
Connections (part):
GND: JP1.3, JP2.4
GND1: JP5.3, JP6.4
GND2: JP9.3, JP10.4
GND3: JP13.3, JP14.4
GND4: JP17.3, JP18.4
GND5: JP21.3, JP22.4
GND6: JP25.3, JP26.4
GND7: JP29.3, JP30.4
GND8: JP33.3, JP34.4
GND9: JP37.3, JP38.4
GND10: JP41.3, JP42.4
GND11: JP45.3, JP46.4
GND12: JP49.3, JP50.4
GND13: JP53.3, JP54.4
GND14: JP57.3, JP58.4
GND15: JP61.3, JP62.4
GND16: JP65.3, JP66.4
GND17: JP69.3, JP70.4
GND18: JP73.3, JP74.4
GND19: JP77.3, JP78.4
GND20: JP81.3, JP82.4
GND21: JP85.3, JP86.4
GND22: JP89.3, JP90.4
GND23: JP93.3, JP94.4
GND24: JP97.3, JP98.4
GND25: JP101.3, JP102.4
GND26: JP105.3, JP106.4
GND27: JP109.3, JP110.4
GND28: JP113.3, JP114.4
GND29: JP117.3, JP118.4
GND30: JP121.3, JP122.4
GND31: JP125.3, JP126.4
GND32: JP129.3, JP130.4
GND33: JP133.3, JP134.4
GND34: JP137.3, JP138.4
GND35: JP141.3, JP142.4
GND36: JP145.3, JP146.4
GND37: JP149.3, JP150.4
GND38: JP153.3, JP154.4
GND39: JP157.3, JP158.4
GND40: JP161.3, JP162.4
GND41: JP165.3, JP166.4
GND42: JP169.3, JP170.4
GND43: JP173.3, JP174.4
GND44: JP177.3, JP178.4
GND45: JP181.3, JP182.4
GND46: JP185.3, JP186.4
GND47: JP189.3, JP190.4
GND48: JP193.3, JP194.4
GND49: JP197.3, JP198.4
GND50: JP201.3, JP202.4
GND51: JP205.3, JP206.4
GND52: JP209.3, JP210.4
GND53: JP213.3, JP214.4
GND54: JP217.3, JP218.4
GND55: JP221.3, JP222.4
GND56: JP225.3, JP226.4
GND57: JP229.3, JP230.4
GND58: JP233.3, JP234.4
GND59: JP237.3, JP238.4
GND60: JP241.3, JP242.4
GND61: JP245.3, JP246.4
GND62: JP249.3, JP250.4
GND63: JP253.3, JP254.4
GND64: JP257.3, JP258.4
GND65: JP261.3, JP262.4
GND66: JP265.3, JP266.4
GND67: JP269.3, JP270.4
GND68: JP273.3, JP274.4
GND69: JP277.3, JP278.4
GND70: JP281.3, JP282.4
GND71: JP285.3, JP286.4
GND72: JP289.3, JP290.4
GND73: JP293.3, JP294.4
GND74: JP297.3, JP298.4
GND75: JP301.3, JP302.4
GND76: JP305.3, JP306.4
GND77: JP309.3, JP310.4
GND78: JP313.3, JP314.4
GND79: JP317.3, JP318.4
GND80: JP321.3, JP322.4
GND81: JP325.3, JP326.4
GND82: JP329.3, JP330.4
GND83: JP333.3, JP334.4
GND84: JP337.3, JP338.4
GND85: JP341.3, JP342.4
GND86: JP345.3, JP346.4
GND87: JP349.3, JP350.4
GND88: JP353.3, JP354.4
GND89: JP357.3, JP358.4
GND90: JP361.3, JP362.4
GND91: JP365.3, JP366.4
GND92: JP369.3, JP370.4
GND93: JP373.3, JP374.4
GND94: JP377.3, JP378.4
GND95: JP381.3, JP382.4
GND96: JP385.3, JP386.4
GND97: JP389.3, JP390.4
GND98: JP393.3, JP394.4
GND99: JP397.3, JP398.4
GND100: JP401.3, JP402.4
GND101: JP405.3, JP406.4
GND102: JP409.3, JP410.4
GND103: JP413.3, JP414.4
GND104: JP417.3, JP418.4
GND105: JP421.3, JP422.4
GND106: JP425.3, JP426.4
GND107: JP429.3, JP430.4
GND108: JP433.3, JP434.4
GND109: JP437.3, JP438.4
GND110: JP441.3, JP442.4
GND111: JP445.3, JP446.4
GND112: JP449.3, JP450.4
GND113: JP453.3, JP454.4
GND114: JP457.3, JP458.4
GND115: JP461.3, JP462.4
GND116: JP465.3, JP466.4
GND117: JP469.3, JP470.4
GND118: JP473.3, JP474.4
GND119: JP477.3, JP478.4
GND120: JP481.3, JP482.4
GND121: JP485.3, JP486.4
GND122: JP489.3, JP490.4
GND123: JP493.3, JP494.4
GND124: JP497.3, JP498.4
GND125: JP501.3, JP502.4
GND126: JP505.3, JP506.4
GND127: JP509.3, JP510.4
GND128: JP513.3, JP514.4
GND129: JP517.3, JP518.4
GND130: JP521.3, JP522.4
GND131: JP525.3, JP526.4
GND132: JP529.3, JP530.4
GND133: JP533.3, JP534.4
GND134: JP537.3, JP538.4
GND135: JP541.3, JP542.4
GND136: JP545.3, JP546.4
GND137: JP549.3, JP550.4
GND138: JP553.3, JP554.4
GND139: JP557.3, JP558.4
GND140: JP561.3, JP562.4
GND141: JP565.3, JP566.4
GND142: JP569.3, JP570.4
GND143: JP573.3, JP574.4
GND144: JP577.3, JP578.4
GND145: JP581.3, JP582.4
GND146: JP585.3, JP586.4
GND147: JP589.3, JP590.4
GND148: JP593.3, JP594.4
GND149: JP597.3, JP598.4
GND150: JP601.3, JP602.4
GND151: JP605.3, JP606.4
GND152: JP609.3, JP610.4
GND153: JP613.3, JP614.4
GND154: JP617.3, JP618.4
GND155: JP621.3, JP622.4
GND156: JP625.3, JP626.4
GND157: JP629.3, JP630.4
GND158: JP633.3, JP634.4
GND159: JP637.3, JP638.4
GND160: JP641.3, JP642.4
GND161: JP645.3, JP646.4
GND162: JP649.3, JP650.4
GND163: JP653.3, JP654.4
GND164: JP657.3, JP658.4
GND165: JP661.3, JP662.4
GND166: JP665.3, JP666.4
GND167: JP669.3, JP670.4
GND168: JP673.3, JP674.4
GND169: JP677.3, JP678.4
GND170: JP681.3, JP682.4
GND171: JP685.3, JP686.4
GND172: JP689.3, JP690.4
GND173: JP693.3, JP694.4
GND174: JP697.3, JP698.4
GND175: JP701.3, JP702.4
GND176: JP705.3, JP706.4
GND177: JP709.3, JP710.4
GND178: JP713.3, JP714.4
GND179: JP717.3, JP718.4
GND180: JP721.3, JP722.4
GND181: JP725.3, JP726.4
GND182: JP729.3, JP730.4
GND183: JP733.3, JP734.4
GND184: JP737.3, JP738.4
GND185: JP741.3, JP742.4
GND186: JP745.3, JP746.4
GND187: JP749.3, JP750.4
GND188: JP753.3, JP754.4
GND189: JP757.3, JP758.4
GND190: JP761.3, JP762.4
GND191: JP765.3, JP766.4
GND192: JP769.3, JP770.4
GND193: JP773.3, JP774.4
GND194: JP777.3, JP778.4
GND195: JP781.3, JP782.4
GND196: JP785.3, JP786.4
GND197: JP789.3, JP790.4
GND198: JP793.3, JP794.4
GND199: JP797.3, JP798.4
GND200: JP801.3, JP802.4
GND201: JP805.3, JP806.4
GND202: JP809.3, JP810.4
GND203: JP813.3, JP814.4
GND204: JP817.3, JP818.4
GND205: JP821.3, JP822.4
GND206: JP825.3, JP826.4
GND207: JP829.3, JP830.4
GND208: JP833.3, JP834.4
GND209: JP837.3, JP838.4
GND210: JP841.3, JP842.4
GND211: JP845.3, JP846.4
GND212: JP849.3, JP850.4
GND213: JP853.3, JP854.4
GND214: JP857.3, JP858.4
GND215: JP861.3, JP862.4
GND216: JP865.3, JP866.4
GND217: JP869.3, JP870.4
GND218: JP873.3, JP874.4
GND219: JP877.3, JP878.4
GND220: JP881.3, JP882.4
GND221: JP885.3, JP886.4
GND222: JP889.3, JP890.4
GND223: JP893.3, JP894.4
HV: JP2.3, R4.1, R5.1, R7.1, R10.1
HV1: JP2.1, Q1.3, R4.2
HV2: JP2.2, Q3.3, R10.2
HV3: JP2.5, Q4.3, R5.2
HV4: JP2.6, Q2.3, R7.2
HV5: JP6.1, Q6.3, R12.2
HV6: JP6.2, Q7.3, R14.2
HV7: JP6.3, R9.1, R12.1, R14.1, R16.1
HV8: JP6.5, Q8.3, R16.2
HV9: JP6.6, Q5.3, R9.2
HV10: JP10.1, Q10.3, R20.2
HV11: JP10.2, Q11.3, R22.2
HV12: JP10.3, R18.1, R20.1, R22.1, R24.1
HV13: JP10.5, Q12.3, R24.2
HV14: JP10.6, Q9.3, R18.2
HV15: JP14.1, Q14.3, R28.2
HV16: JP14.2, Q15.3, R30.2
HV17: JP14.3, R26.1, R28.1, R30.1, R32.1
HV18: JP14.5, Q16.3, R32.2
HV19: JP14.6, Q13.3, R26.2
HV20: JP18.1, Q18.3, R36.2
HV21: JP18.2, Q19.3, R38.2
HV22: JP18.3, R34.1, R36.1, R38.1, R40.1
HV23: JP18.5, Q20.3, R40.2
HV24: JP18.6, Q17.3, R34.2
HV25: JP22.1, Q22.3, R44.2
HV26: JP22.2, Q23.3, R46.2
HV27: JP22.3, R42.1, R44.1, R46.1, R48.1
HV28: JP22.5, Q24.3, R48.2
HV29: JP22.6, Q21.3, R42.2
HV30: JP26.1, Q26.3, R52.2
HV31: JP26.2, Q27.3, R54.2
HV32: JP26.3, R50.1, R52.1, R54.1, R56.1
HV33: JP26.5, Q28.3, R56.2
HV34: JP26.6, Q25.3, R50.2
HV35: JP30.1, Q30.3, R60.2
HV36: JP30.2, Q31.3, R62.2
HV37: JP30.3, R58.1, R60.1, R62.1, R64.1
HV38: JP30.5, Q32.3, R64.2
HV39: JP30.6, Q29.3, R58.2
HV40: JP34.1, Q34.3, R68.2
HV41: JP34.2, Q35.3, R70.2
HV42: JP34.3, R66.1, R68.1, R70.1, R72.1
HV43: JP34.5, Q36.3, R72.2
HV44: JP34.6, Q33.3, R66.2
HV45: JP38.1, Q38.3, R76.2
HV46: JP38.2, Q39.3, R78.2
HV47: JP38.3, R74.1, R76.1, R78.1, R80.1
HV48: JP38.5, Q40.3, R80.2
HV49: JP38.6, Q37.3, R74.2
HV50: JP42.1, Q42.3, R84.2
HV51: JP42.2, Q43.3, R86.2
HV52: JP42.3, R82.1, R84.1, R86.1, R88.1
HV53: JP42.5, Q44.3, R88.2
HV54: JP42.6, Q41.3, R82.2
HV55: JP46.1, Q46.3, R92.2
HV56: JP46.2, Q47.3, R94.2
HV57: JP46.3, R90.1, R92.1, R94.1, R96.1
HV58: JP46.5, Q48.3, R96.2
HV59: JP46.6, Q45.3, R90.2
HV60: JP50.1, Q50.3, R100.2
HV61: JP50.2, Q51.3, R102.2
HV62: JP50.3, R98.1, R100.1, R102.1, R104.1
HV63: JP50.5, Q52.3, R104.2
HV64: JP50.6, Q49.3, R98.2
HV65: JP54.1, Q54.3, R108.2
HV66: JP54.2, Q55.3, R110.2
HV67: JP54.3, R106.1, R108.1, R110.1, R112.1
HV68: JP54.5, Q56.3, R112.2
HV69: JP54.6, Q53.3, R106.2
HV70: JP58.1, Q58.3, R116.2
HV71: JP58.2, Q59.3, R118.2
HV72: JP58.3, R114.1, R116.1, R118.1, R120.1
HV73: JP58.5, Q60.3, R120.2
HV74: JP58.6, Q57.3, R114.2
HV75: JP62.1, Q62.3, R124.2
HV76: JP62.2, Q63.3, R126.2
HV77: JP62.3, R122.1, R124.1, R126.1, R128.1
HV78: JP62.5, Q64.3, R128.2
HV79: JP62.6, Q61.3, R122.2
HV80: JP66.1, Q66.3, R132.2
HV81: JP66.2, Q67.3, R134.2
HV82: JP66.3, R130.1, R132.1, R134.1, R136.1
HV83: JP66.5, Q68.3, R136.2
HV84: JP66.6, Q65.3, R130.2
HV85: JP70.1, Q70.3, R140.2
HV86: JP70.2, Q71.3, R142.2
HV87: JP70.3, R138.1, R140.1, R142.1, R144.1
HV88: JP70.5, Q72.3, R144.2
HV89: JP70.6, Q69.3, R138.2
HV90: JP74.1, Q74.3, R148.2
HV91: JP74.2, Q75.3, R150.2
HV92: JP74.3, R146.1, R148.1, R150.1, R152.1
HV93: JP74.5, Q76.3, R152.2
HV94: JP74.6, Q73.3, R146.2
HV95: JP78.1, Q78.3, R156.2
HV96: JP78.2, Q79.3, R158.2
HV97: JP78.3, R154.1, R156.1, R158.1, R160.1
HV98: JP78.5, Q80.3, R160.2
HV99: JP78.6, Q77.3, R154.2
HV100: JP82.1, Q82.3, R164.2
HV101: JP82.2, Q83.3, R166.2
HV102: JP82.3, R162.1, R164.1, R166.1, R168.1
HV103: JP82.5, Q84.3, R168.2
HV104: JP82.6, Q81.3, R162.2
HV105: JP86.1, Q86.3, R172.2
HV106: JP86.2, Q87.3, R174.2
HV107: JP86.3, R170.1, R172.1, R174.1, R176.1
HV108: JP86.5, Q88.3, R176.2
HV109: JP86.6, Q85.3, R170.2
HV110: JP90.1, Q90.3, R180.2
HV111: JP90.2, Q91.3, R182.2
HV112: JP90.3, R178.1, R180.1, R182.1, R184.1
HV113: JP90.5, Q92.3, R184.2
HV114: JP90.6, Q89.3, R178.2
HV115: JP94.1, Q94.3, R188.2
HV116: JP94.2, Q95.3, R190.2
HV117: JP94.3, R186.1, R188.1, R190.1, R192.1
HV118: JP94.5, Q96.3, R192.2
HV119: JP94.6, Q93.3, R186.2
HV120: JP98.1, Q98.3, R196.2
HV121: JP98.2, Q99.3, R198.2
HV122: JP98.3, R194.1, R196.1, R198.1, R200.1
HV123: JP98.5, Q100.3, R200.2
HV124: JP98.6, Q97.3, R194.2
HV125: JP102.1, Q102.3, R204.2
HV126: JP102.2, Q103.3, R206.2
HV127: JP102.3, R202.1, R204.1, R206.1, R208.1
HV128: JP102.5, Q104.3, R208.2
HV129: JP102.6, Q101.3, R202.2
HV130: JP106.1, Q106.3, R212.2
HV131: JP106.2, Q107.3, R214.2
HV132: JP106.3, R210.1, R212.1, R214.1, R216.1
HV133: JP106.5, Q108.3, R216.2
HV134: JP106.6, Q105.3, R210.2
HV135: JP110.1, Q110.3, R220.2
HV136: JP110.2, Q111.3, R222.2
HV137: JP110.3, R218.1, R220.1, R222.1, R224.1
HV138: JP110.5, Q112.3, R224.2
HV139: JP110.6, Q109.3, R218.2
HV140: JP114.1, Q114.3, R228.2
HV141: JP114.2, Q115.3, R230.2
HV142: JP114.3, R226.1, R228.1, R230.1, R232.1
HV143: JP114.5, Q116.3, R232.2
HV144: JP114.6, Q113.3, R226.2
HV145: JP118.1, Q118.3, R236.2
HV146: JP118.2, Q119.3, R238.2
HV147: JP118.3, R234.1, R236.1, R238.1, R240.1
HV148: JP118.5, Q120.3, R240.2
HV149: JP118.6, Q117.3, R234.2
HV150: JP122.1, Q122.3, R244.2
HV151: JP122.2, Q123.3, R246.2
HV152: JP122.3, R242.1, R244.1, R246.1, R248.1
HV153: JP122.5, Q124.3, R248.2
HV154: JP122.6, Q121.3, R242.2
HV155: JP126.1, Q126.3, R252.2
HV156: JP126.2, Q127.3, R254.2
HV157: JP126.3, R250.1, R252.1, R254.1, R256.1
HV158: JP126.5, Q128.3, R256.2
HV159: JP126.6, Q125.3, R250.2
HV160: JP130.1, Q130.3, R260.2
HV161: JP130.2, Q131.3, R262.2
HV162: JP130.3, R258.1, R260.1, R262.1, R264.1
HV163: JP130.5, Q132.3, R264.2
HV164: JP130.6, Q129.3, R258.2
HV165: JP134.1, Q134.3, R268.2
HV166: JP134.2, Q135.3, R270.2
HV167: JP134.3, R266.1, R268.1, R270.1, R272.1
HV168: JP134.5, Q136.3, R272.2
HV169: JP134.6, Q133.3, R266.2
HV170: JP138.1, Q138.3, R276.2
HV171: JP138.2, Q139.3, R278.2
HV172: JP138.3, R274.1, R276.1, R278.1, R280.1
HV173: JP138.5, Q140.3, R280.2
HV174: JP138.6, Q137.3, R274.2
HV175: JP142.1, Q142.3, R284.2
HV176: JP142.2, Q143.3, R286.2
HV177: JP142.3, R282.1, R284.1, R286.1, R288.1
HV178: JP142.5, Q144.3, R288.2
HV179: JP142.6, Q141.3, R282.2
HV180: JP146.1, Q146.3, R292.2
HV181: JP146.2, Q147.3, R294.2
HV182: JP146.3, R290.1, R292.1, R294.1, R296.1
HV183: JP146.5, Q148.3, R296.2
HV184: JP146.6, Q145.3, R290.2
HV185: JP150.1, Q150.3, R300.2
HV186: JP150.2, Q151.3, R302.2
HV187: JP150.3, R298.1, R300.1, R302.1, R304.1
HV188: JP150.5, Q152.3, R304.2
HV189: JP150.6, Q149.3, R298.2
HV190: JP154.1, Q154.3, R308.2
HV191: JP154.2, Q155.3, R310.2
HV192: JP154.3, R306.1, R308.1, R310.1, R312.1
HV193: JP154.5, Q156.3, R312.2
HV194: JP154.6, Q153.3, R306.2
HV195: JP158.1, Q158.3, R316.2
HV196: JP158.2, Q159.3, R318.2
HV197: JP158.3, R314.1, R316.1, R318.1, R320.1
HV198: JP158.5, Q160.3, R320.2
HV199: JP158.6, Q157.3, R314.2
HV200: JP162.1, Q162.3, R324.2
HV201: JP162.2, Q163.3, R326.2
HV202: JP162.3, R322.1, R324.1, R326.1, R328.1
HV203: JP162.5, Q164.3, R328.2
HV204: JP162.6, Q161.3, R322.2
HV205: JP166.1, Q166.3, R332.2
HV206: JP166.2, Q167.3, R334.2
HV207: JP166.3, R330.1, R332.1, R334.1, R336.1
HV208: JP166.5, Q168.3, R336.2
HV209: JP166.6, Q165.3, R330.2
HV210: JP170.1, Q170.3, R340.2
HV211: JP170.2, Q171.3, R342.2
HV212: JP170.3, R338.1, R340.1, R342.1, R344.1
HV213: JP170.5, Q172.3, R344.2
HV214: JP170.6, Q169.3, R338.2
HV215: JP174.1, Q174.3, R348.2
HV216: JP174.2, Q175.3, R350.2
HV217: JP174.3, R346.1, R348.1, R350.1, R352.1
HV218: JP174.5, Q176.3, R352.2
HV219: JP174.6, Q173.3, R346.2
HV220: JP178.1, Q178.3, R356.2
HV221: JP178.2, Q179.3, R358.2
HV222: JP178.3, R354.1, R356.1, R358.1, R360.1
HV223: JP178.5, Q180.3, R360.2
HV224: JP178.6, Q177.3, R354.2
HV225: JP182.1, Q182.3, R364.2
HV226: JP182.2, Q183.3, R366.2
HV227: JP182.3, R362.1, R364.1, R366.1, R368.1
HV228: JP182.5, Q184.3, R368.2
HV229: JP182.6, Q181.3, R362.2
HV230: JP186.1, Q186.3, R372.2
HV231: JP186.2, Q187.3, R374.2
HV232: JP186.3, R370.1, R372.1, R374.1, R376.1
HV233: JP186.5, Q188.3, R376.2
HV234: JP186.6, Q185.3, R370.2
HV235: JP190.1, Q190.3, R380.2
HV236: JP190.2, Q191.3, R382.2
HV237: JP190.3, R378.1, R380.1, R382.1, R384.1
HV238: JP190.5, Q192.3, R384.2
HV239: JP190.6, Q189.3, R378.2
HV240: JP194.1, Q194.3, R388.2
HV241: JP194.2, Q195.3, R390.2
HV242: JP194.3, R386.1, R388.1, R390.1, R392.1
HV243: JP194.5, Q196.3, R392.2
HV244: JP194.6, Q193.3, R386.2
HV245: JP198.1, Q198.3, R396.2
HV246: JP198.2, Q199.3, R398.2
HV247: JP198.3, R394.1, R396.1, R398.1, R400.1
HV248: JP198.5, Q200.3, R400.2
HV249: JP198.6, Q197.3, R394.2
HV250: JP202.1, Q202.3, R404.2
HV251: JP202.2, Q203.3, R406.2
HV252: JP202.3, R402.1, R404.1, R406.1, R408.1
HV253: JP202.5, Q204.3, R408.2
HV254: JP202.6, Q201.3, R402.2
HV255: JP206.1, Q206.3, R412.2
HV256: JP206.2, Q207.3, R414.2
HV257: JP206.3, R410.1, R412.1, R414.1, R416.1
HV258: JP206.5, Q208.3, R416.2
HV259: JP206.6, Q205.3, R410.2
HV260: JP210.1, Q210.3, R420.2
HV261: JP210.2, Q211.3, R422.2
HV262: JP210.3, R418.1, R420.1, R422.1, R424.1
HV263: JP210.5, Q212.3, R424.2
HV264: JP210.6, Q209.3, R418.2
HV265: JP214.1, Q214.3, R428.2
HV266: JP214.2, Q215.3, R430.2
HV267: JP214.3, R426.1, R428.1, R430.1, R432.1
HV268: JP214.5, Q216.3, R432.2
HV269: JP214.6, Q213.3, R426.2
HV270: JP218.1, Q218.3, R436.2
HV271: JP218.2, Q219.3, R438.2
HV272: JP218.3, R434.1, R436.1, R438.1, R440.1
HV273: JP218.5, Q220.3, R440.2
HV274: JP218.6, Q217.3, R434.2
HV275: JP222.1, Q222.3, R444.2
HV276: JP222.2, Q223.3, R446.2
HV277: JP222.3, R442.1, R444.1, R446.1, R448.1
HV278: JP222.5, Q224.3, R448.2
HV279: JP222.6, Q221.3, R442.2
HV280: JP226.1, Q226.3, R452.2
HV281: JP226.2, Q227.3, R454.2
HV282: JP226.3, R450.1, R452.1, R454.1, R456.1
HV283: JP226.5, Q228.3, R456.2
HV284: JP226.6, Q225.3, R450.2
HV285: JP230.1, Q230.3, R460.2
HV286: JP230.2, Q231.3, R462.2
HV287: JP230.3, R458.1, R460.1, R462.1, R464.1
HV288: JP230.5, Q232.3, R464.2
HV289: JP230.6, Q229.3, R458.2
HV290: JP234.1, Q234.3, R468.2
HV291: JP234.2, Q235.3, R470.2
HV292: JP234.3, R466.1, R468.1, R470.1, R472.1
HV293: JP234.5, Q236.3, R472.2
HV294: JP234.6, Q233.3, R466.2
HV295: JP238.1, Q238.3, R476.2
HV296: JP238.2, Q239.3, R478.2
HV297: JP238.3, R474.1, R476.1, R478.1, R480.1
HV298: JP238.5, Q240.3, R480.2
HV299: JP238.6, Q237.3, R474.2
HV300: JP242.1, Q242.3, R484.2
HV301: JP242.2, Q243.3, R486.2
HV302: JP242.3, R482.1, R484.1, R486.1, R488.1
HV303: JP242.5, Q244.3, R488.2
HV304: JP242.6, Q241.3, R482.2
HV305: JP246.1, Q246.3, R492.2
HV306: JP246.2, Q247.3, R494.2
HV307: JP246.3, R490.1, R492.1, R494.1, R496.1
HV308: JP246.5, Q248.3, R496.2
HV309: JP246.6, Q245.3, R490.2
HV310: JP250.1, Q250.3, R500.2
HV311: JP250.2, Q251.3, R502.2
HV312: JP250.3, R498.1, R500.1, R502.1, R504.1
HV313: JP250.5, Q252.3, R504.2
HV314: JP250.6, Q249.3, R498.2
HV315: JP254.1, Q254.3, R508.2
HV316: JP254.2, Q255.3, R510.2
HV317: JP254.3, R506.1, R508.1, R510.1, R512.1
HV318: JP254.5, Q256.3, R512.2
HV319: JP254.6, Q253.3, R506.2
HV320: JP258.1, Q258.3, R516.2
HV321: JP258.2, Q259.3, R518.2
HV322: JP258.3, R514.1, R516.1, R518.1, R520.1
HV323: JP258.5, Q260.3, R520.2
HV324: JP258.6, Q257.3, R514.2
HV325: JP262.1, Q262.3, R524.2
HV326: JP262.2, Q263.3, R526.2
HV327: JP262.3, R522.1, R524.1, R526.1, R528.1
HV328: JP262.5, Q264.3, R528.2
HV329: JP262.6, Q261.3, R522.2
HV330: JP266.1, Q266.3, R532.2
HV331: JP266.2, Q267.3, R534.2
HV332: JP266.3, R530.1, R532.1, R534.1, R536.1
HV333: JP266.5, Q268.3, R536.2
HV334: JP266.6, Q265.3, R530.2
HV335: JP270.1, Q270.3, R540.2
HV336: JP270.2, Q271.3, R542.2
HV337: JP270.3, R538.1, R540.1, R542.1, R544.1
HV338: JP270.5, Q272.3, R544.2
HV339: JP270.6, Q269.3, R538.2
HV340: JP274.1, Q274.3, R548.2
HV341: JP274.2, Q275.3, R550.2
HV342: JP274.3, R546.1, R548.1, R550.1, R552.1
HV343: JP274.5, Q276.3, R552.2
HV344: JP274.6, Q273.3, R546.2
HV345: JP278.1, Q278.3, R556.2
HV346: JP278.2, Q279.3, R558.2
HV347: JP278.3, R554.1, R556.1, R558.1, R560.1
HV348: JP278.5, Q280.3, R560.2
HV349: JP278.6, Q277.3, R554.2
HV350: JP282.1, Q282.3, R564.2
HV351: JP282.2, Q283.3, R566.2
HV352: JP282.3, R562.1, R564.1, R566.1, R568.1
HV353: JP282.5, Q284.3, R568.2
HV354: JP282.6, Q281.3, R562.2
HV355: JP286.1, Q286.3, R572.2
HV356: JP286.2, Q287.3, R574.2
HV357: JP286.3, R570.1, R572.1, R574.1, R576.1
HV358: JP286.5, Q288.3, R576.2
HV359: JP286.6, Q285.3, R570.2
HV360: JP290.1, Q290.3, R580.2
HV361: JP290.2, Q291.3, R582.2
HV362: JP290.3, R578.1, R580.1, R582.1, R584.1
HV363: JP290.5, Q292.3, R584.2
HV364: JP290.6, Q289.3, R578.2
HV365: JP294.1, Q294.3, R588.2
HV366: JP294.2, Q295.3, R590.2
HV367: JP294.3, R586.1, R588.1, R590.1, R592.1
HV368: JP294.5, Q296.3, R592.2
HV369: JP294.6, Q293.3, R586.2
HV370: JP298.1, Q298.3, R596.2
HV371: JP298.2, Q299.3, R598.2
HV372: JP298.3, R594.1, R596.1, R598.1, R600.1
HV373: JP298.5, Q300.3, R600.2
HV374: JP298.6, Q297.3, R594.2
HV375: JP302.1, Q302.3, R604.2
HV376: JP302.2, Q303.3, R606.2
HV377: JP302.3, R602.1, R604.1, R606.1, R608.1
HV378: JP302.5, Q304.3, R608.2
HV379: JP302.6, Q301.3, R602.2
HV380: JP306.1, Q306.3, R612.2
HV381: JP306.2, Q307.3, R614.2
HV382: JP306.3, R610.1, R612.1, R614.1, R616.1
HV383: JP306.5, Q308.3, R616.2
HV384: JP306.6, Q305.3, R610.2
HV385: JP310.1, Q310.3, R620.2
HV386: JP310.2, Q311.3, R622.2
HV387: JP310.3, R618.1, R620.1, R622.1, R624.1
HV388: JP310.5, Q312.3, R624.2
HV389: JP310.6, Q309.3, R618.2
HV390: JP314.1, Q314.3, R628.2
HV391: JP314.2, Q315.3, R630.2
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